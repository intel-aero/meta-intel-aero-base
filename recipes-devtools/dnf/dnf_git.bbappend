FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += "file://0001-dnf-update-to-2.3.0.patch \
	    file://0002-dnf-fix-upstream-version-check.patch \
	"
